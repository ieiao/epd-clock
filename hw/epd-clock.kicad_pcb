# Repository ieiao/epd-clock

File README.md:

# EPD-CLOCK

## 简介

本项目使用了2.9寸电子价签中的墨水屏，出于个人爱好制作而成，目前仅设计了简单的基础功能，实物效果如下。

经过估算，低功耗状态下的待机电流应该小于20uA，因测量设备不足无法测量故刷新功耗不详，单节电池可用寿命不详。经过简单测试，工作5周，每天工作时间16小时，电池电压从1.57V降至1.42V，仅供参考。

## 源码目录

```
├── fw                  # 固件
│   ├── binloader       #  SPI flash烧录固件，基于flashrom的serprog协议
│   └── clock           #  主固件
└── hw                  # 硬件，原理图、PCB及相关内容
```

## 硬件简介

本项目使用的墨水屏、MCU、SPI flash均来自电子价签，使用单节7号干电池升压供电，详细原理图及元器件信息见`hw`目录，本项目原理图等使用`KiCAD`进行绘制。

## 固件编译

项目中涉及到的两个固件程序均使用CMake进行管理，GCC作为编译器，在Debian 11发行版中进行构建。

## 字库烧录

本项目字库未采用全字库方案，而是只取了部分使用的字体，使用genmatrix([gitee](https://gitee.com/ieiao/genmatrix)|[github](https://github.com/ieiao/genmatrix))工具`xxd_format`分支进行了字符取模，使用`fw/binloader`程序来进行字库烧录。

`binloader`是[flashrom](https://flashrom.org/Flashrom)工具中serprog协议的一种实现，借助串口实现对spi flash内容的读写，虽然速度一般，但足以应对本项目使用的超小体积字库。

成功编译并且将binloader程序烧录到单片机后，使用任意USB转TTL串口连接设备与电脑，此时便可以借助flashrom对SPI flash进行烧录了，烧录文件见`fw/clock/flash/font.bin`。

> 如果不介意烧录速度慢的话可以将字库文件pad一段数据到flash容量大小后进行全片烧录；如果介意烧录速度的话可以使用flashrom的layout特性仅烧录指定的部分，或者使用其他高速烧录器烧录后再进行焊接。

## 主程序说明

主程序目前只实现了时间日期显示及调节、电池电压监测以及简易的夜间模式，基本满足看时间的需求。

## KiCad design hw/epd-clock.kicad_pcb

Parts:
C1: 1uF; C_0603_1608Metric
C2: 0.1uF; C_0603_1608Metric
C3, C4, C21: 10uF; C_1206_3216Metric
C5, C6: 10uF; C_0805_2012Metric
C7: 0.1uF/25V; C_0603_1608Metric
C8, C9, C10, C11, C14, C16, C18: 1uF/25V; C_0603_1608Metric
C12, C15: 1uF/50V; C_0603_1608Metric
C13: 10uF/6V; C_0603_1608Metric
C17: 4.7uF/50V; C_0805_2012Metric
C19: 1uF/6V; C_0603_1608Metric
C20: 100uF; C_1206_3216Metric
D1: 1N5819; D_SOD-323
D2, D3, D4: MBR0530; D_SOD-123
J1: uart; PinHeader_1x03_P2.54mm_Vertical_SMD_Pin1Left
J2: USBC; USB_C_Receptacle_Palconn_UTC16-G
J3: Battery; JST_SH_BM02B-SRSS-TB_1x02-1MP_P1.00mm_Vertical
J4: Conn_01x24_MountingPin; TE_2-1734839-4_1x24-1MP_P0.5mm_Horizontal
L1: 10uH; L_Coilcraft_XxL4020
Q1, Q3: 3401; SOT-23
Q2: 8050; SOT-23
Q4: IRLML6344; SOT-23
R1, R2, R3, R6, R7, R9: 10K; R_0603_1608Metric
R4, R5: 5.1K; R_0603_1608Metric
R8, R14: 1K; R_0603_1608Metric
R10: 100K; R_0603_1608Metric
R11, R13, R16: 4.7K; R_0603_1608Metric
R12: 1M; R_0603_1608Metric
R15: 3R; R_0603_1608Metric
R17: 0R; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
SW1: BT0; SW_Push_SPST_NO_Alps_SKRK
SW2: BT1; SW_Push_SPST_NO_Alps_SKRK
U1: ESP32-C3-WROOM-02
U2: TC4056A; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U3: ME6210A33PG; SOT-89-3

Connections:
+3V3: C6.2, C7.1, C10.1, C13.2, C20.1, C21.1, J4.9, J4.10, L1.2, R1.1, R2.1, R3.2, R11.1, R16.1, U1.1 (3V3), U3.3 (VOUT)
+BATT: C4.2, J3.2, Q1.3 (D), Q3.2 (S), R9.1, U2.5 (BAT)
-BATT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, D2.1 (K), J1.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.1, J4.8, J4.17, J4.MP (MountPin), Q2.2 (E), R4.2, R5.2, R6.1, R7.1, R10.2, R12.2, R14.2, R15.2, SW1.1, SW2.1, U1.9 (GND), U1.19 (EPAD), U2.1 (TEMP), U2.3 (GND), U3.1 (GND)
/ADC1_CH3: R13.2, R14.1, U1.15 (IO3)
/CHIP_PU: C1.2, R1.2, U1.2 (EN)
/CHRG: J1.2, U1.12 (TXD), U2.7 (CHRG)
/EPD_BUSY: J4.16, U1.3 (IO4)
/EPD_CLK: J4.12, U1.5 (IO6)
/EPD_CS: J4.13, U1.10 (IO10)
/EPD_DC: J4.14, R2.2, U1.7 (IO8)
/EPD_DIN: J4.11, U1.6 (IO7)
/EPD_RST: J4.15, U1.4 (IO5)
/FSPIQ: R3.1, U1.16 (IO2)
/GDR: J4.23, Q4.1 (G), R12.1
/IO0: SW1.2, U1.18 (IO0)
/IO1: U1.17 (IO1), U2.6 (STDBY)
/IO9: SW2.2, U1.8 (IO9)
/IO20: J1.3, R8.1, U1.11 (RXD)
/PREVGH: C12.1, D4.1 (K), J4.4
/PREVGL: C15.1, D3.2 (A), J4.2
/RESE: J4.22, Q4.2 (S), R15.1
/TSCL: J4.19, R16.2
/TSDA: J4.18, R11.2
/USB_D+: J2.A6 (D+), J2.B6 (D+), U1.14 (IO19)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U1.13 (IO18)
/VCOM: C19.1, J4.1
/VDD: C11.1, J4.7
/VGH: C8.1, J4.20
/VGL: C9.1, J4.21
/VPP: C14.1, J4.6
/VSH: C16.1, J4.5
/VSL: C18.1, J4.3
unnamed: C17.1, D4.2 (A), L1.1, Q4.3 (D)
unnamed: C17.2, D2.2 (A), D3.1 (K)
unnamed: D1.1 (K), Q1.2 (S), R17.1
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R5.1
unnamed: Q2.1 (B), R8.2, R10.1
unnamed: Q2.3 (C), Q3.1 (G), R9.2
unnamed: Q3.3 (D), R13.1
unnamed: R6.2, U2.2 (PROG)
VBUS: C2.2, C3.2, D1.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), Q1.1 (G), R7.2, U2.4 (VCC), U2.8 (CE)
VCC: C5.2, R17.2, U3.2 (VIN)

Notes on the sheet:
RST#
VSL
PREVGL
TSDA
EPD RST PIN
BS1
CLK
VGH
strap引脚，手动进入下载模式
充电完成指示 低电平有效
VGL
GND
VCOM
PREVGH
4 wire spi
ADC电池电压测量
电池电压检测开关
DIN
SPI MOSI
2R2 3R 0.47R
BUSY
VSH
SPI CS
IO0用作输入按键，用来唤醒系统
DC#
正在充电指示 低电平有效
不使用USB CDC时使用物理串口输出调试信息
TSCL
STRAP
RESE
IO2/IO8按照数据手册Download Boot 模式要求保持上拉状态
GDR
VDDIO
VCI
SPI MISO 上拉 留空
VDD
SPI CLK
VPP
CS#
EPD BUSY PIN

Board: 2 copper layers, 86.0 x 43.7 mm, 56 parts (56 on the bottom side), 43 nets.

## Commit log

2021-08-14 epd-clock: v0.1
2021-08-14 epd-clock: hw v0.2
2021-08-14 epd-clock: binloader v0.1
2021-08-14 epd-clock hw: add i2c test point
2021-08-15 epd-clock: hw add wakeup pin pull up register
2021-08-15 epd-clock: hw change C8 footprint
2021-08-18 epd-clock: hw: v0.2
2021-08-29 epd-clock: binloader change baud to 115200
2021-08-29 epd-clock: 初步增加一些代码
2021-09-05 epd-clock: binloader修改适配v0.2版本的原理图
2021-09-09 epd-clock: 屏幕绘制,字符串处理,字库检索初步进行了验证
2021-09-12 epd-clock: 低功耗逻辑进行了初步验证，增加了按键检测的实现
2021-09-23 hw: 修正几个元件的参数
2021-10-31 fw clock: 添加基础校时功能
2021-10-31 fw: clock: 完善功能
2021-11-01 hw: 合并电源网络
    取消墨水屏电源控制mos与独立电源域，墨水屏使用深度休眠模式，共用主
    电源域。
2021-11-19 增加README说明文档
2021-11-27 更新ibom
2021-11-27 更新电池使用情况
2021-12-05 fw: clock: 优化按键长按的检测逻辑
2021-12-05 fw: clock: 调整电量检测计算方法，减小程序文件体积
2022-10-30 Rebuild based on ESP32C3, initial work done.
